
require recipes-core/images/mng-image-rdkb.bb

SUMMARY = "OFW Image"
