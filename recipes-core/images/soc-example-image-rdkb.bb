
require recipes-core/images/mng-image-rdkb.bb

require soc-example-image-minimal.inc
require soc-example-image-base.inc
require soc-example-image-rdkb.inc
