
require recipes-core/images/mng-image-minimal.bb

require soc-example-image-minimal.inc
