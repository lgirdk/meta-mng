
require recipes-core/images/mng-image-base.bb

require soc-example-image-minimal.inc
require soc-example-image-base.inc
