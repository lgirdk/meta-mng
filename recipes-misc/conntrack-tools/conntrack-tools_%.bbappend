
FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "file://0001-fix-address-family-data-type-for-nfct_query-and-nfex.patch"

