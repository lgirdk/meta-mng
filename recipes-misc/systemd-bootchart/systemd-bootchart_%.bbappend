
FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI_append = " file://0001-drop-dependency-on-getrandom.patch"
